# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: WHEELTEC +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: .\Start;.\System;.\User\App;.\User\Core;.\User\Config;.\Library\inc;.\Hardware
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ./User/Core/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Hardware
    ./Hardware/: adc.c can.c encoder.c key.c LED.C motor.c oled.c pstwo.c timer.c usartx.c adc.h can.h DataScope_DP.h dma.h encoder.h exti.h I2C.h key.h LED.H motor.h mpu6050.h oled.h oledfont.h pstwo.h stmflash.h timer.h usartx.h
  group System
    ./System/: delay.c sys.c usart.c
  group Start
    ./Start/: startup_stm32f40_41xxx.s
  group Library
    ./Library/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_pwr.c
  group App
    ./User/App/: balance.c DataScope_DP.C filter.c robot_select_init.c show.c system.c
  group MPU6050
    ./Hardware/: I2C.c MPU6050.c
